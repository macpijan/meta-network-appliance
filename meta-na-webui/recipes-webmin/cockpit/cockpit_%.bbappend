PACKAGECONFIG:append = " dashboard"
