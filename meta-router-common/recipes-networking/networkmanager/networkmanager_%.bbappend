PACKAGECONFIG_append = " wifi modemmanager"
