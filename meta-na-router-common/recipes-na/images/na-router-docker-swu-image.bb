# It must be set before the require statement
OTAB_ROOTFS_IMAGE_NAME = "na-router-docker-image"

require recipes-otab/images/otab-image.inc
